Commit message: PD control

File: boxbot.urdf (robot description, URDF)
Before this commit: robot boxbot, 2 links, 1 joints
Links:
- link base_link: mass .05 -> .25
